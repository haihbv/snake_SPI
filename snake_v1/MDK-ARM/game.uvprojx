# Keil uVision project game.uvprojx, settings and files
target __snakeVN (6140000::V6.14::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: snake
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Cores;..\Drivers;..\Drivers\Bitmap;..\Multi_Tasks;..\Ui
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../Cores/: main.c
  group Drivers
    ../Drivers/: delay.c gpio.c spi.c st7735.c
  group Multi_Tasks
    ../Multi_Tasks/: button.c snake.c task.c
  group Fonts
    ../Drivers/: fonts.c
  group Ui
    ../Ui/: ui.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0
